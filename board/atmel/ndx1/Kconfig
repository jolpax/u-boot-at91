## board/atmel/ndx1/Kconfig
```kconfig
if TARGET_NCX1

config SYS_BOARD
	default "ncx1"

config SYS_VENDOR
	default "cabsy"

config SYS_CONFIG_NAME
	default "ncx1"

endif
```
